# Keil uVision project project.uvprojx, settings and files
target Flash (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER, STM32H743xx,USE_USBD_FS
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32H7xx\Include;..\..\Libraries\STM32H7xx_HAL_Driver\Inc;..\..\User\segger\RTT Viewer\RTT;..\..\User\bsp\inc;..\..\User\fonts;..\..\User;..\..\User\bsp;..\..\User\applib;..\..\uCOS-III\uC-CPU\ARM-Cortex-M\ARMv7-M\ARM;..\..\uCOS-III\uC-CPU\Cfg\Template;..\..\uCOS-III\uC-CPU\Template;..\..\uCOS-III\uC-CPU;..\..\uCOS-III\uC-LIB;..\..\uCOS-III\uC-LIB\Cfg\Template;..\..\uCOS-III\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\..\uCOS-III\uCOS-III\Source;..\..\uCOS-III\uCOS-III\Ports\ARM-Cortex-M\ARMv7-M\ARM;..\..\uCOS-III\uCOS-III\Cfg\Template;..\..\Libraries\FatFs\src;..\..\Libraries\FatFs\src\drivers;..\..\Libraries\STM32_USB_Device_Library\Core\Inc;..\..\Libraries\STM32_USB_Device_Library\Class\MSC\Inc;..\..\User\usbd_mass_storage;..\..\emWin\Include;..\..\emWin\emWinTask;..\..\emWin\emWinDemo;..\..\emWin\JPEGConf;..\..\emWin\Config;..\..\emWin\User;..\..\User\malloc
  library: MicroLIB
  memory RVCT1: ROM 0x90000000 size 0x2000000
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  link misc: --diag_suppress 6314
  group User
    ../../User/: main.c includes.h app_cfg.h
    ../../uCOS-III/uCOS-III/Cfg/Template/: os_cfg.h os_cfg_app.h os_app_hooks.c
    ../../uCOS-III/uC-CPU/Cfg/Template/: cpu_cfg.h
    ../../uCOS-III/uC-LIB/Cfg/Template/: lib_cfg.h
  group APP_Lib
    ../../User/applib/: App_SysFunction.c app_audio_lib.c app_wav_lib.c
  group BSP
    ../../User/bsp/: bsp.c bsp.h bsp_clk.c bsp_cpu.c bsp_os.c stm32h7xx_it.c bsp_int_armv7m.c
    ../../User/bsp/src/: bsp_led.c bsp_key.c bsp_timer.c bsp_beep.c bsp_fmc_io.c bsp_camera.c bsp_uart_fifo.c bsp_sdio_sd.c bsp_tim_pwm.c bsp_i2c_gpio.c bsp_fmc_sdram.c bsp_i2c_eeprom_24xx.c bsp_cpu_rtc.c bsp_spi_bus.c bsp_spi_flash.c bsp_i2c_wm8978.c bsp_fmc_ad7606.c
    ../../User/: stm32h7xx_hal_timebase_tim.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group HAL_Driver
    ../../User/bsp/: stm32h7xx_hal_conf.h
    ../../Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_gpio.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_mdma.c stm32h7xx_hal_sdram.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_dma2d.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_qspi.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_sai.c stm32h7xx_hal_i2s_ex.c
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group FatFS
    ../../Libraries/FatFs/src/: ff.c ffconf.h diskio.c ff_gen_drv.c
    ../../Libraries/FatFs/src/option/: cc936.c syscall.c
    ../../Libraries/FatFs/src/drivers/: sd_diskio_dma.c
  group SEGGER/HardFault
    ../../User/segger/HardFaultHandlerMDK/: HardFaultHandler.S SEGGER_HardFaultHandler.c
  group SEGGER/RTT
    ../../User/segger/RTT Viewer/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group uC/CPU
    ../../uCOS-III/uC-CPU/: cpu_core.c
    ../../uCOS-III/uC-CPU/ARM-Cortex-M/ARMv7-M/: cpu_c.c
    ../../uCOS-III/uC-CPU/ARM-Cortex-M/ARMv7-M/ARM/: cpu_a.asm
  group uC/LIB
    ../../uCOS-III/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uC/OS-III Source
    ../../uCOS-III/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uC/OS-III Port
    ../../uCOS-III/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/ARM/: os_cpu.h os_cpu_a.asm os_cpu_isr.asm
    ../../uCOS-III/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
  group GUI/Driver
    ../../User/bsp/src/: bsp_tft_h7.c bsp_ts_touch.c bsp_tft_lcd.c bsp_ts_ft5x06.c bsp_ts_gt811.c bsp_ts_gt911.c bsp_ts_stmpe811.c
  group GUI/GUI_OS
    ../../emWin/GUI_X/: GUI_X_uCOS-III.c
  group GUI/Config
    ../../emWin/Config/: GUIConf.c GUIConf.h LCDConf_Lin_Template.c LCDConf_Lin_Template.h
  group GUI/Task
    ../../emWin/emWinTask/: GUI_Main.c GUI_Camera_DLG.c GUI_Clock_DLG.c GUI_Reserved_DLG.c GUI_Calendar_DLG.c GUI_Music_DLG.c GUI_Setting_DLG.c GUI_DrawingBoard_DLG.c GUI_Picture_DLG.c GUI_Oscilloscope_DLG.c
  group GUI/JPEG
    ../../emWin/JPEGConf/: decode_dma.c decode_dma.h JPEGConf.c JPEGConf.h
  group GUI/Lib
    ../../emWin/GUILib/: GUI_CM4F_L.lib
  group GUI/User
    ../../emWin/User/: GUI_BMPdisplay.c
  group GUI/Font
    ../../emWin/HanZi/: gb2312.c
  group GUI/Hanzi
    ../../emWin/HanZi/: GUI_Font12.c GUI_Font16.c GUI_Font24.c GUI_Font32.c GUI_Font48.c GUI_UC_EncodeNone.c GUICharPEx.c
  group GUI/Pic
    ../../emWin/Bitmap/: Background_clock.c Button_appoint.c Button_lock.c Button_unlock.c ClockBkPic.c colon.c next.c num0.c num1.c num2.c num3.c num4.c num5.c num6.c num7.c num8.c num9.c pause.c play.c previous.c recorder_cancel.c recorder_play.c recorder_record.c recorder_save.c brush.c eraser.c Switch.c _settings.c
  group GUI/Icon
    ../../emWin/Icon/: calculator.c calendar.c camera.c clock.c codedlock.c control.c drawingboard.c folder.c game.c gps.c lamplight.c music.c mycomputer.c news.c oscilloscope.c picture.c radio.c recorder.c setting.c usb.c video.c
  group Font
    ../../User/fonts/: asc12.c asc16.c asc24.c asc32.c hz12.c hz16.c hz24.c hz32.c ra8875_asc_width.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt
  group Malloc
    ../../User/malloc/: rt_Memory.c
